Commit message: ur10e_shadowhand

File: src/curobo/content/assets/robot/shadowhand_description/shadowhand.urdf (robot description, URDF)
Before this commit: robot shadowhand, 30 links, 29 joints
Joints:
- joint WRJ2: type fixed -> revolute
